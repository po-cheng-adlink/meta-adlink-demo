require pyqt5-kiosk.inc

SRCSERVER = "git://github.com/po-cheng-adlink/pyqt5-kiosk.git;protocol=https;user=${PRIVATE_USER}:${PRIVATE_TOKEN};"
SRCBRANCH = "rel_kiosk_v2022.03.01"
SRCREV = "fd357c80aa9770708c5635ae3fb0f9005f022b31"

