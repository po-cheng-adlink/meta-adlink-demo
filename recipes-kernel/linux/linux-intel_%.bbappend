FILESEXTRAPATHS_prepend := "${THISDIR}/linux-intel:"

SRC_URI_append = " file://enable_blkdev_nbd.cfg"

